# Keil uVision project Fire_FreeRTOS.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::..\..\..\Program Files\Keil_v5\ARM\ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: YH-RT-Thread
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\User;..\freertos\Source\include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group user
    ../User/: main.c
  group FreeRTOS/Ports
    ../freertos/Source/include/: portmacro.h
  group FreeRTOS/Source
    ../freertos/Source/include/: list.h FreeRTOSConfig.h portmacro.h task.h portable.h FreeRTOS.h projdefs.h
    ../freertos/Source/: list.c task.c
    ../freertos/Source/portable/RVDS/ARM_CM3/: port.c
software components: CMSIS:CORE 5.1.1, Device:Startup 1.0.1
